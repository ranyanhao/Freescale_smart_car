# Keil uVision project uCOS-II.uvproj, settings and files
target uCOS-II (ARM-ADS)
  device: MK60DN512xxx10 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: uCOS-II +hex
  c flags: Optim=1
  c define: MK60D10 RAVEN DEBUG
  c misc: --c99
  c include: ..\USER;..\Libraries\devices\src;..\Libraries\drivers\K\src;..\uCOS-II\Source;..\uCOS-II\Ports\ARM-Cortex-M4\Generic\RealView;..\Libraries\startup\CoreSupport;..\Libraries\startup\DeviceSupport\MDK-ARM;..\Libraries\devices\inc;..\Libraries\drivers\K\inc;..\Libraries\startup\DeviceSupport;..\BSP;..\APP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Startup
    ../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK60D10.s
  group USER
    ../USER/: main.c
  group Libraries
    ../Libraries/drivers/K/src/: adc.c can.c common.c cpuidy.c dac.c dma.c enet.c flexbus.c ftm.c gpio.c i2c.c lptmr.c pit.c rtc.c sd.c spi.c systick.c tsi.c uart.c vref.c wdog.c
  group APP
    ../APP/: includes.h cpu_cfg.h app_hooks.c os_cfg.h app_cfg.h app.c
  group BSP
    ../Libraries/startup/DeviceSupport/: MK60D10.h system_MK60D10.c
    ../BSP/: BSP.c pid.c servo_control.c ccd.c dip_switch.c OLED.c
  group uCOS-II Ports
    ../uCOS-II/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uCOS-II Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
